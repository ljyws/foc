# Keil uVision project foc_software.uvprojx, settings and files
target foc_software (6190000::V6.19::ARMCLANG)
  device: STM32G474RETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: foc_software +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32G474xx
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../Bsp;../Drv;../Tools;../USB_Device/App;../USB_Device/Target;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../MotorCtrl
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32g474xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c spi.c tim.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_pcd.c stm32g4xx_hal_pcd_ex.c stm32g4xx_ll_usb.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Drv
    ../Drv/: drv_led.c drv_encoder.c
  group Bsp
    ../Bsp/: bsp_gpio_op.c bsp_spi_op.c bsp_adc_op.c
  group MotorCtrl
    ../MotorCtrl/: foc.c motor.c low_level.c board.c controller.c open_loop_controller.c
  group Tools
    ../Tools/: utils.c vofa.c
  group Application/User/USB_Device/Target
    ../USB_Device/Target/: usbd_conf.c
  group Application/User/USB_Device/App
    ../USB_Device/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: CMSIS:CORE 5.6.0
